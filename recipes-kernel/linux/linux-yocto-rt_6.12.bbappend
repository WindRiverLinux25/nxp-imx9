require linux-yocto-nxp-imx9.inc

KBRANCH:nxp-imx9  = "v6.12/standard/preempt-rt/nxp-sdk-6.12/nxp-soc"
